# IAR project hd44780.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: hd44780.hex
  ILINK.IlinkOutputFile: hd44780.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: 1wire.c 1wire.h delay.c delay.h main.c stm8s_conf.h
    ../interfacing_hd44780_lcd_fw/AN4032/Projects/HD44780/src/: HD44780.c
    ../interfacing_hd44780_lcd_fw/AN4032/Projects/HD44780/inc/: HD44780.h
    ../interfacing_hd44780_lcd_fw/AN4032/Projects/HD44780_template/inc/: main.h stm8s_it.h
    ../Изменение частоты мигания светодиодов при нажатии сенсорной кнопки/an3279/Project/Discover/inc/: stm8_tsl_conf.h
    ../interfacing_hd44780_lcd_fw/AN4032/Projects/HD44780_template/src/: stm8s_it.c
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_gpio.h stm8s_itc.h stm8s_tim3.h
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_gpio.c stm8s_itc.c stm8s_tim3.c
